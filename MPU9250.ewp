# IAR project MPU9250.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F427VI ST STM32F427VI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F427_437xx; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: STM32F4xx_StdPeriph_Driver\inc; CMSIS\Device\ST\STM32F4xx\Include; CMSIS\Include; User\inc; Hardware\inc; Module\inc; FatFs\inc; Malloc\inc; FreeRTOS\Source\include; FreeRTOS\Source\portable\IAR\ARM_CM4F; Application\inc; DLL\inc; HAL\inc; Algorithm\inc; Control\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: User\inc
  OBJCOPY.OOCOutputFile: MPU9250.srec
  ILINK.IlinkOutputFile: MPU9250.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration STM32F4 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Algorithm
    Algorithm/src/: MadgwickAHRS.c MahonyAHRS.c
  group Application
    Application/src/: LedSeq.c system.c
  group CMSIS
    CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Control
    Control/src/: controller.c pid.c pidctrl.c stabilizer.c
  group DLL
    DLL/src/: commander.c ComModule.c CRTP.c RadioLink.c
  group Doc
    User/: readme.txt
  group EWARM
    CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f401xx.s startup_stm32f40_41xxx.s startup_stm32f40xx.s startup_stm32f410xx.s startup_stm32f411xe.s startup_stm32f412xg.s startup_stm32f427_437xx.s startup_stm32f427x.s startup_stm32f429_439xx.s startup_stm32f446xx.s startup_stm32f469_479xx.s
  group FatFs
    FatFs/option/: cc936.c
    FatFs/src/: diskio.c ff.c
  group FreeRTOS
    FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
    FreeRTOS/Source/portable/MemMang/: heap_2.c
    FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group HAL
    HAL/src/: IMU.c
  group Hardware
    Hardware/src/: BoardDefine.c
  group Malloc
    Malloc/src/: malloc.c
  group Module
    Module/src/: HMC5983.c ICM20601.c MPU9250.c nRF24L01.c PPM_Encode.c sdio_sd.c
  group STM32F4xx_StdPeriph_Driver
    STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group User
    User/: main.c stm32f4xx_it.c
